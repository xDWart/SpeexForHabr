# IAR project SpeexForHabr.ewp, settings and files
configuration SpeexForHabr (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; HAVE_CONFIG_H
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/STM32F10x_Speex_Lib/include; ../Drivers/STM32F10x_Speex_Lib/libspeex; ../Drivers/STM32F10x_Speex_Lib/STM32; ../Drivers/STM32F10x_Speex_Lib/STM32/include; ../Drivers/STM32F10x_Speex_Lib/STM32/libspeex; ../Drivers/STM32F10x_Speex_Lib/STM32/libspeex/iar
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: SpeexForHabr.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c speexx.c speexx.h stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/libspeex
    ../Drivers/STM32F10x_Speex_Lib/libspeex/: bits.c buffer.c exc_10_32_table.c gain_table.c gain_table_lbr.c high_lsp_tables.c lpc.c lsp.c lsp_tables_nb.c speex.c speex_callbacks.c speex_header.c window.c
    ../Drivers/STM32F10x_Speex_Lib/STM32/libspeex/: cb_search.c filters.c ltp.c modes.c nb_celp.c quant_lsp.c vq.c
    ../Drivers/STM32F10x_Speex_Lib/STM32/libspeex/iar/: filters_cortexM3.s ltp_cortexM3.s vq_cortexm3.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
